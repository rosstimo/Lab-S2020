File: S2020/temp.sch (KiCad schematic (older format))
At the start: 28 parts

Commit message: mess
Parts:
- gave numbers to parts that had none: 27
